v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 10600 -4690 10770 -4690 { lab=#net1}
N 10660 -4690 10660 -4470 { lab=#net1}
N 10660 -4410 10660 -3810 { lab=#net2}
N 10540 -3810 10750 -3810 { lab=#net2}
N 10390 -4690 10480 -4690 { lab=a1}
N 10360 -3810 10420 -3810 { lab=c1}
N 10280 -4690 10280 -4660 { lab=a1}
N 10280 -4690 10400 -4690 { lab=a1}
N 10360 -3810 10360 -3780 { lab=c1}
N 10830 -4690 10870 -4690 { lab=#net3}
N 10810 -3810 10840 -3810 { lab=#net4}
N 10900 -3810 10930 -3810 { lab=GND}
N 10990 -3810 11020 -3810 { lab=GND}
N 10930 -4690 10940 -4690 { lab=GND}
N 11000 -4690 11030 -4690 { lab=GND}
N 10940 -4690 11010 -4690 { lab=GND}
N 10930 -3810 11000 -3810 { lab=GND}
N 6120 -3970 6120 -3900 { lab=#net5}
N 6120 -3970 6270 -3970 { lab=#net5}
N 6270 -3970 6270 -3950 { lab=#net5}
N 6120 -3840 6120 -3820 { lab=#net6}
N 6120 -3760 6120 -3700 { lab=#net7}
N 6000 -3910 6120 -3910 { lab=#net5}
N 6000 -3850 6000 -3830 { lab=#net6}
N 6000 -3830 6120 -3830 { lab=#net6}
N 6270 -3970 6480 -3970 { lab=#net5}
N 6120 -3470 6120 -3450 { lab=#net8}
N 6120 -3390 6120 -3340 { lab=GND}
N 6000 -3470 6000 -3450 { lab=#net8}
N 6000 -3530 6120 -3530 { lab=#net7}
N 6000 -3450 6120 -3450 { lab=#net8}
N 6530 -3970 6530 -3900 { lab=#net5}
N 6530 -3840 6530 -3820 { lab=#net9}
N 6530 -3760 6530 -3700 { lab=#net10}
N 6410 -3910 6530 -3910 { lab=#net5}
N 6410 -3850 6410 -3830 { lab=#net9}
N 6410 -3830 6530 -3830 { lab=#net9}
N 6530 -3470 6530 -3450 { lab=#net11}
N 6530 -3390 6530 -3340 { lab=GND}
N 6410 -3470 6410 -3450 { lab=#net11}
N 6410 -3530 6530 -3530 { lab=#net10}
N 6410 -3450 6530 -3450 { lab=#net11}
N 6480 -3970 6530 -3970 { lab=#net5}
N 6530 -3700 6530 -3530 { lab=#net10}
N 6120 -3700 6120 -3530 { lab=#net7}
N 6730 -3100 6780 -3100 { lab=b}
N 6780 -3100 6860 -3100 { lab=b}
N 6990 -3210 7090 -3210 { lab=#net12}
N 6870 -3170 6870 -3100 { lab=b}
N 6860 -3100 6870 -3100 { lab=b}
N 6900 -3210 6990 -3210 { lab=#net12}
N 6680 -3210 6840 -3210 { lab=#net7}
N 6890 -3170 6890 -3040 { lab=GND}
N 6900 -3410 6950 -3410 { lab=d}
N 6950 -3410 7030 -3410 { lab=d}
N 7040 -3480 7040 -3410 { lab=d}
N 7030 -3410 7040 -3410 { lab=d}
N 6850 -3520 7010 -3520 { lab=#net10}
N 7060 -3480 7060 -3350 { lab=GND}
N 6700 -3520 6850 -3520 { lab=#net10}
N 6660 -3210 6690 -3210 { lab=#net7}
N 6120 -3650 6250 -3650 { lab=#net7}
N 6250 -3650 6250 -3210 { lab=#net7}
N 6250 -3210 6670 -3210 { lab=#net7}
N 6530 -3600 6700 -3600 { lab=#net10}
N 6700 -3600 6700 -3520 { lab=#net10}
N 7130 -3700 7130 -3210 { lab=#net12}
N 7090 -3210 7130 -3210 { lab=#net12}
N 7070 -3520 7130 -3520 { lab=#net12}
N 6900 -3410 6950 -3410 { lab=d}
N 7730 -3990 7780 -3990 { lab=c}
N 7780 -3990 7860 -3990 { lab=c}
N 7870 -4060 7870 -3990 { lab=c}
N 7860 -3990 7870 -3990 { lab=c}
N 7890 -4060 7890 -3930 { lab=GND}
N 8210 -3990 8260 -3990 { lab=a}
N 8260 -3990 8340 -3990 { lab=a}
N 8350 -4060 8350 -3990 { lab=a}
N 8340 -3990 8350 -3990 { lab=a}
N 8370 -4060 8370 -3930 { lab=GND}
N 7720 -3580 7770 -3580 { lab=a}
N 7770 -3580 7850 -3580 { lab=a}
N 7860 -3650 7860 -3580 { lab=a}
N 7850 -3580 7860 -3580 { lab=a}
N 7880 -3650 7880 -3520 { lab=GND}
N 8200 -3580 8250 -3580 { lab=c}
N 8250 -3580 8330 -3580 { lab=c}
N 8340 -3650 8340 -3580 { lab=c}
N 8330 -3580 8340 -3580 { lab=c}
N 8360 -3650 8360 -3520 { lab=GND}
N 7890 -3690 8310 -3690 { lab=#net13}
N 7900 -4100 8330 -4100 { lab=#net14}
N 8380 -4100 8390 -4100 { lab=vcntl}
N 8390 -4100 8560 -4100 { lab=vcntl}
N 8560 -4100 8560 -3690 { lab=vcntl}
N 8370 -3690 8380 -3690 { lab=vcntl}
N 8380 -3690 8560 -3690 { lab=vcntl}
N 8180 -3860 8200 -3860 { lab=#net15}
N 8200 -3860 8200 -3830 { lab=#net15}
N 8100 -4290 8120 -4290 { lab=#net16}
N 8120 -4290 8120 -4260 { lab=#net16}
N 8010 -4180 8010 -4100 { lab=#net14}
N 8010 -4290 8010 -4240 { lab=#net16}
N 8010 -4290 8110 -4290 { lab=#net16}
N 8100 -3860 8100 -3800 { lab=#net15}
N 8100 -3860 8180 -3860 { lab=#net15}
N 8100 -3740 8100 -3690 { lab=#net13}
N 7410 -4100 7840 -4100 { lab=#net17}
N 7410 -4100 7410 -3700 { lab=#net17}
N 7410 -3690 7830 -3690 { lab=#net17}
N 7410 -3720 7410 -3690 { lab=#net17}
N 8560 -4100 8670 -4100 { lab=vcntl}
N 9300 -4780 9330 -4780 { lab=#net18}
N 9300 -4860 9300 -4780 { lab=#net18}
N 9300 -4860 9500 -4860 { lab=#net18}
N 9500 -4860 9500 -4690 { lab=#net18}
N 9460 -4690 9500 -4690 { lab=#net18}
N 9460 -4780 9530 -4780 { lab=#net19}
N 9530 -4780 9530 -4720 { lab=#net19}
N 9330 -4600 9370 -4600 { lab=o}
N 9330 -4690 9330 -4650 { lab=oi}
N 9330 -4650 9550 -4650 { lab=oi}
N 9550 -4650 9550 -4600 { lab=oi}
N 9530 -4600 9550 -4600 { lab=oi}
N 9440 -4600 9460 -4600 { lab=#net20}
N 9750 -4770 9780 -4770 { lab=c}
N 9750 -4850 9750 -4770 { lab=c}
N 9750 -4850 9950 -4850 { lab=c}
N 9950 -4850 9950 -4680 { lab=c}
N 9910 -4680 9950 -4680 { lab=c}
N 9910 -4770 9980 -4770 { lab=a}
N 9980 -4770 9980 -4710 { lab=a}
N 9540 -4680 9780 -4680 { lab=#net19}
N 9980 -4710 10160 -4710 { lab=a}
N 10160 -4740 10160 -4710 { lab=a}
N 9530 -4720 9530 -4680 { lab=#net19}
N 9530 -4680 9540 -4680 { lab=#net19}
N 9770 -4400 9800 -4400 { lab=d}
N 9770 -4480 9770 -4400 { lab=d}
N 9770 -4480 9970 -4480 { lab=d}
N 9970 -4480 9970 -4310 { lab=d}
N 9930 -4310 9970 -4310 { lab=d}
N 9930 -4400 10000 -4400 { lab=b}
N 10000 -4400 10000 -4340 { lab=b}
N 9660 -4680 9660 -4540 { lab=#net19}
N 9660 -4470 9660 -4310 { lab=#net21}
N 9660 -4310 9800 -4310 { lab=#net21}
N 10000 -4340 10080 -4340 { lab=b}
N 9950 -4680 10030 -4680 { lab=c}
N 9970 -4310 10030 -4310 { lab=d}
N 8670 -4600 8670 -4100 { lab=vcntl}
N 7130 -3700 7240 -3700 { lab=#net12}
N 7300 -3700 7410 -3700 { lab=#net17}
N 10280 -4660 10280 -4580 { lab=a1}
N 10360 -3780 10360 -3710 { lab=c1}
N 8970 -4600 9040 -4600 { lab=vcntl}
N 8670 -4600 8970 -4600 { lab=vcntl}
C {res.sym} 10510 -4690 1 0 {name=R3
value=135k
footprint=1206
device=resistor
m=1}
C {capa.sym} 10570 -4690 1 0 {name=C1
m=1
value=4.7p
footprint=1206
device="ceramic capacitor"}
C {res.sym} 10450 -3810 1 0 {name=R4
value=135k
footprint=1206
device=resistor
m=1}
C {capa.sym} 10510 -3810 1 0 {name=C2
m=1
value=4.7p
footprint=1206
device="ceramic capacitor"}
C {capa.sym} 10660 -4440 2 0 {name=C3
m=1
value=2.35p
footprint=1206
device="ceramic capacitor"}
C {res.sym} 10800 -4690 1 0 {name=R6
value=135k
footprint=1206
device=resistor
m=1}
C {res.sym} 10780 -3810 1 0 {name=R7
value=135k
footprint=1206
device=resistor
m=1}
C {code_shown.sym} 7880 -4830 0 0 {name=CONTROL place=end value=".tran 1n 1m
.save v(vcntl) v(oi) v(a) v(b) v(c) v(d) i(vip1) i(vim1) v(net13) v(net14) i(vdd_sup3)

 "}
C {vsource.sym} 10900 -4690 3 0 {name=vip1 value=0}
C {gnd.sym} 11030 -4690 0 0 {name=l1 lab=GND}
C {vsource.sym} 10870 -3810 3 0 {name=vim1 value=0}
C {gnd.sym} 11020 -3810 0 0 {name=l2 lab=GND}
C {cccs.sym} 6120 -3870 0 0 {name=F2 vnam=vim1 value=1}
C {gnd.sym} 6270 -3900 0 0 {name=l4 lab=GND}
C {vsource.sym} 6270 -3930 0 0 {name=vin_dc2 value=1.666}
C {gnd.sym} 6270 -3900 0 0 {name=l5 lab=GND}
C {gnd.sym} 6270 -3900 0 0 {name=l6 lab=GND}
C {vsource.sym} 6120 -3790 0 0 {name=vip5 value=0}
C {res.sym} 6000 -3880 2 0 {name=R5
value=10Meg
footprint=1206
device=resistor
m=1}
C {cccs.sym} 6120 -3500 0 0 {name=F4 vnam=vip1 value=1}
C {gnd.sym} 6120 -3340 0 0 {name=l8 lab=GND}
C {vsource.sym} 6120 -3420 0 0 {name=vip7 value=0}
C {res.sym} 6000 -3500 2 0 {name=R8
value=10Meg
footprint=1206
device=resistor
m=1}
C {vsource.sym} 6530 -3790 0 0 {name=vip8 value=0}
C {res.sym} 6410 -3880 2 0 {name=R9
value=10Meg
footprint=1206
device=resistor
m=1}
C {gnd.sym} 6530 -3340 0 0 {name=l13 lab=GND}
C {vsource.sym} 6530 -3420 0 0 {name=vip9 value=0}
C {res.sym} 6410 -3500 2 0 {name=R10
value=10Meg
footprint=1206
device=resistor
m=1}
C {cccs.sym} 6530 -3870 0 0 {name=F5 vnam=vip1 value=1}
C {cccs.sym} 6530 -3500 0 0 {name=F6 vnam=vim1 value=1}
C {switch_ngspice.sym} 6870 -3210 3 0 {name=S1 model=swmod}
C {gnd.sym} 6890 -3040 0 0 {name=l14 lab=GND}
C {switch_ngspice.sym} 7040 -3520 3 0 {name=S4 model=swmod}
C {gnd.sym} 7060 -3350 0 0 {name=l18 lab=GND}
C {code.sym} 8290 -4930 0 0 {
name=TT_model_sky130
format=@value
only_toplevel=true
value="
*.lib ~/open_pdks/sky130/sky130A/libs.tech/ngspice/sky130.lib.spice tt
.param mc_mm_switch=0
.param mc_pr_switch=0

.include ~/open_pdks/sky130/sky130A/libs.tech/ngspice/corners/tt/nonfet.spice


*model
.include ~/open_pdks/sky130/sky130A/libs.tech/ngspice/all.spice

*mosfet
.include ~/open_pdks/sky130/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__tt.corner.spice
.inclued ~/open_pdks/sky130/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__tt.corner.spice

*mismatch parameters
.include ~/open_pdks/sky130/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__mismatch.corner.spice
.include ~/open_pdks/sky130/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__mismatch.corner.spice
*mosfet
.include ~/open_pdks/sky130/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__tt.corner.spice
.inclued ~/open_pdks/sky130/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__tt.corner.spice

*mismatch parameters
.include ~/open_pdks/sky130/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice
.include ~/open_pdks/sky130/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice
.MODEL swmod SW(VT=0.9 VH=0.01 RON=1 ROFF=10000000000)
"
spice_ignore=false

}
C {switch_ngspice.sym} 7870 -4100 3 0 {name=S5 model=swmod}
C {gnd.sym} 7890 -3930 0 0 {name=l20 lab=GND}
C {switch_ngspice.sym} 8350 -4100 3 0 {name=S6 model=swmod}
C {gnd.sym} 8370 -3930 0 0 {name=l22 lab=GND}
C {switch_ngspice.sym} 7860 -3690 3 0 {name=S7 model=swmod}
C {gnd.sym} 7880 -3520 0 0 {name=l24 lab=GND}
C {switch_ngspice.sym} 8340 -3690 3 0 {name=S8 model=swmod}
C {gnd.sym} 8360 -3520 0 0 {name=l26 lab=GND}
C {capa.sym} 8010 -4210 2 0 {name=C4
m=1
value=80p
footprint=1206
device="ceramic capacitor"}
C {capa.sym} 8100 -3770 2 0 {name=C6
m=1
value=80p
footprint=1206
device="ceramic capacitor"}
C {vsource.sym} 8200 -3800 0 0 {name=vdd_sup1 value=1.8}
C {gnd.sym} 8200 -3770 0 0 {name=l27 lab=GND}
C {vsource.sym} 8120 -4230 0 0 {name=vdd_sup2 value=1.8}
C {gnd.sym} 8120 -4200 0 0 {name=l28 lab=GND}
C {lab_pin.sym} 8550 -4100 1 0 {name=l9 sig_type=std_logic lab=vcntl}
C {/home/cegrahul/Downloads/TSPC_Dff.sym} 9400 -4730 0 0 {name=xTSPC_Dff1}
C {lab_pin.sym} 10160 -4740 2 0 {name=l10 sig_type=std_logic lab=a}
C {/home/cegrahul/Desktop/SSCS/inverter.sym} 650 -2130 0 0 {name=X2}
C {/home/cegrahul/Desktop/SSCS/inverter.sym} 740 -2130 0 0 {name=X3}
C {lab_pin.sym} 9350 -4600 3 0 {name=l11 sig_type=std_logic lab=o}
C {/home/cegrahul/Downloads/TSPC_Dff.sym} 9850 -4720 0 0 {name=xTSPC_Dff2}
C {/home/cegrahul/Downloads/TSPC_Dff.sym} 9870 -4350 0 0 {name=xTSPC_Dff3}
C {/home/cegrahul/Desktop/SSCS/inverter.sym} 7190 -13260 1 0 {name=X4}
C {lab_pin.sym} 10080 -4340 2 0 {name=l15 sig_type=std_logic lab=b}
C {lab_pin.sym} 10030 -4680 2 0 {name=l16 sig_type=std_logic lab=c}
C {lab_pin.sym} 10030 -4310 2 0 {name=l17 sig_type=std_logic lab=d}
C {lab_pin.sym} 9550 -4600 3 0 {name=l19 sig_type=std_logic lab=oi}
C {lab_pin.sym} 6730 -3100 3 0 {name=l3 sig_type=std_logic lab=b}
C {lab_pin.sym} 6900 -3410 3 0 {name=l21 sig_type=std_logic lab=d}
C {lab_pin.sym} 8210 -3990 3 0 {name=l23 sig_type=std_logic lab=a}
C {lab_pin.sym} 7720 -3580 3 0 {name=l25 sig_type=std_logic lab=a}
C {lab_pin.sym} 8200 -3580 3 0 {name=l29 sig_type=std_logic lab=c}
C {lab_pin.sym} 7730 -3990 3 0 {name=l30 sig_type=std_logic lab=c}
C {/home/cegrahul/Desktop/ro_lvt.sym} 9190 -4600 0 0 {name=x1}
C {vsource.sym} 7270 -3700 3 0 {name=vdd_sup3 value=0}
C {vcvs.sym} 9150 -5020 0 1 {name=E1 value=0.1}
C {vcvs.sym} 9440 -5020 0 1 {name=E2 value=0.1}
C {lab_pin.sym} 9190 -5040 2 0 {name=l31 sig_type=std_logic lab=a}
C {lab_pin.sym} 9480 -5040 2 0 {name=l32 sig_type=std_logic lab=c}
C {gnd.sym} 9480 -5000 0 0 {name=l33 lab=GND}
C {gnd.sym} 9440 -4990 0 0 {name=l34 lab=GND}
C {gnd.sym} 9190 -5000 0 0 {name=l35 lab=GND}
C {gnd.sym} 9150 -4990 0 0 {name=l36 lab=GND}
C {lab_pin.sym} 9150 -5050 2 0 {name=l37 sig_type=std_logic lab=a1}
C {lab_pin.sym} 9440 -5050 2 0 {name=l38 sig_type=std_logic lab=c1}
C {lab_pin.sym} 10280 -4580 2 0 {name=l7 sig_type=std_logic lab=a1}
C {lab_pin.sym} 10360 -3710 2 0 {name=l12 sig_type=std_logic lab=c1}
