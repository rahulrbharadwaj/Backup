v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 4190 -750 4240 -750 { lab=x}
N 4240 -750 4320 -750 { lab=x}
N 4330 -820 4330 -750 { lab=x}
N 4320 -750 4330 -750 { lab=x}
N 4350 -820 4350 -690 { lab=GND}
N 4670 -750 4720 -750 { lab=w}
N 4720 -750 4800 -750 { lab=w}
N 4810 -820 4810 -750 { lab=w}
N 4800 -750 4810 -750 { lab=w}
N 4830 -820 4830 -690 { lab=GND}
N 4180 -340 4230 -340 { lab=w}
N 4230 -340 4310 -340 { lab=w}
N 4320 -410 4320 -340 { lab=w}
N 4310 -340 4320 -340 { lab=w}
N 4340 -410 4340 -280 { lab=GND}
N 4660 -340 4710 -340 { lab=x}
N 4710 -340 4790 -340 { lab=x}
N 4800 -410 4800 -340 { lab=x}
N 4790 -340 4800 -340 { lab=x}
N 4820 -410 4820 -280 { lab=GND}
N 4350 -450 4770 -450 { lab=#net1}
N 4360 -860 4790 -860 { lab=#net2}
N 4840 -860 4850 -860 { lab=vcntl}
N 4850 -860 5020 -860 { lab=vcntl}
N 5020 -860 5020 -450 { lab=vcntl}
N 4830 -450 4840 -450 { lab=vcntl}
N 4840 -450 5020 -450 { lab=vcntl}
N 4640 -620 4660 -620 { lab=#net3}
N 4660 -620 4660 -590 { lab=#net3}
N 4560 -1050 4580 -1050 { lab=#net4}
N 4580 -1050 4580 -1020 { lab=#net4}
N 4470 -940 4470 -860 { lab=#net2}
N 4470 -1050 4470 -1000 { lab=#net4}
N 4470 -1050 4570 -1050 { lab=#net4}
N 4560 -620 4560 -560 { lab=#net3}
N 4560 -620 4640 -620 { lab=#net3}
N 4560 -500 4560 -450 { lab=#net1}
N 3870 -860 4300 -860 { lab=#net5}
N 3870 -860 3870 -460 { lab=#net5}
N 3870 -450 4290 -450 { lab=#net5}
N 3870 -480 3870 -450 { lab=#net5}
N 3590 -460 3870 -460 { lab=#net5}
N 5020 -860 5130 -860 { lab=vcntl}
N 5760 -1540 5790 -1540 { lab=#net6}
N 5760 -1620 5760 -1540 { lab=#net6}
N 5760 -1620 5960 -1620 { lab=#net6}
N 5960 -1620 5960 -1450 { lab=#net6}
N 5920 -1450 5960 -1450 { lab=#net6}
N 5920 -1540 5990 -1540 { lab=#net7}
N 5990 -1540 5990 -1480 { lab=#net7}
N 5790 -1360 5830 -1360 { lab=o}
N 5790 -1450 5790 -1410 { lab=oi}
N 5790 -1410 6010 -1410 { lab=oi}
N 6010 -1410 6010 -1360 { lab=oi}
N 5990 -1360 6010 -1360 { lab=oi}
N 5900 -1360 5920 -1360 { lab=#net8}
N 6210 -1530 6240 -1530 { lab=x}
N 6210 -1610 6210 -1530 { lab=x}
N 6210 -1610 6410 -1610 { lab=x}
N 6410 -1610 6410 -1440 { lab=x}
N 6370 -1440 6410 -1440 { lab=x}
N 6370 -1530 6440 -1530 { lab=w}
N 6440 -1530 6440 -1470 { lab=w}
N 6000 -1440 6240 -1440 { lab=#net7}
N 6440 -1470 6620 -1470 { lab=w}
N 6620 -1500 6620 -1470 { lab=w}
N 5990 -1480 5990 -1440 { lab=#net7}
N 5990 -1440 6000 -1440 { lab=#net7}
N 6230 -1160 6260 -1160 { lab=z}
N 6230 -1240 6230 -1160 { lab=z}
N 6230 -1240 6430 -1240 { lab=z}
N 6430 -1240 6430 -1070 { lab=z}
N 6390 -1070 6430 -1070 { lab=z}
N 6390 -1160 6460 -1160 { lab=y}
N 6460 -1160 6460 -1100 { lab=y}
N 6120 -1440 6120 -1300 { lab=#net7}
N 6120 -1230 6120 -1070 { lab=#net9}
N 6120 -1070 6260 -1070 { lab=#net9}
N 6460 -1100 6540 -1100 { lab=y}
N 6410 -1440 6490 -1440 { lab=x}
N 6430 -1070 6490 -1070 { lab=z}
N 3260 -460 3610 -460 { lab=#net5}
N 5130 -860 5560 -860 { lab=vcntl}
N 1970 -1270 2250 -1270 { lab=#net10}
N 1930 -1360 2290 -1360 { lab=#net11}
N 1870 -1270 1930 -1270 { lab=#net11}
N 1870 -1450 1870 -1270 { lab=#net11}
N 1870 -1450 1960 -1450 { lab=#net11}
N 1960 -1450 2360 -1450 { lab=#net11}
N 2290 -1270 2360 -1270 { lab=#net11}
N 2360 -1290 2360 -1270 { lab=#net11}
N 1970 -990 2250 -990 { lab=#net12}
N 1930 -1120 2000 -1120 { lab=#net12}
N 2000 -1120 2000 -990 { lab=#net12}
N 1900 -1190 1930 -1190 { lab=#net11}
N 1900 -1270 1900 -1190 { lab=#net11}
N 2290 -1190 2320 -1190 { lab=#net11}
N 1970 -1450 1970 -1360 { lab=#net11}
N 2320 -1270 2320 -1190 { lab=#net11}
N 2360 -1450 2360 -1270 { lab=#net11}
N 2290 -1130 2310 -1130 { lab=#net13}
N 1870 -1120 1870 -1090 { lab=#net14}
N 1870 -1090 1930 -1090 { lab=#net14}
N 2230 -1130 2290 -1130 { lab=#net13}
N 2230 -1160 2230 -1130 { lab=#net13}
N 1870 -1160 1870 -1140 { lab=#net12}
N 1870 -1140 1930 -1140 { lab=#net12}
N 1930 -1140 1930 -1120 { lab=#net12}
N 2230 -1130 2230 -1090 { lab=#net13}
N 1930 -1240 2070 -1240 { lab=c}
N 2170 -1240 2290 -1240 { lab=d}
N 2480 -1130 3230 -1130 { lab=#net5}
N 3220 -1130 3220 -470 { lab=#net5}
N 3220 -470 3220 -460 { lab=#net5}
N 3220 -460 3260 -460 { lab=#net5}
N 2370 -1130 2480 -1130 { lab=#net5}
N 5490 -1360 5490 -1170 { lab=vcntl}
N 5490 -1170 5560 -1170 { lab=vcntl}
N 5560 -1170 5560 -860 { lab=vcntl}
N 890 -1300 1010 -1300 { lab=#net15}
N 890 -1280 1010 -1280 { lab=#net16}
N 860 -1310 890 -1310 { lab=#net15}
N 890 -1310 890 -1300 { lab=#net15}
N 860 -1250 890 -1250 { lab=#net16}
N 890 -1280 890 -1250 { lab=#net16}
C {code_shown.sym} 3740 -1160 0 0 {name=CONTROL place=end value=".tran 1n 10u
.save all
"}
C {code.sym} 3570 -1210 0 0 {
name=TT_model_sky130
format=@value
only_toplevel=true
value="
.lib ~/open_pdks/sky130/sky130A/libs.tech/ngspice/sky130.lib.spice tt
.MODEL swmod SW(VT=0.9 VH=0.0 RON=1 ROFF=10000000000)
"
spice_ignore=false

}
C {switch_ngspice.sym} 4330 -860 3 0 {name=S5 model=swmod}
C {gnd.sym} 4350 -690 0 0 {name=l20 lab=GND}
C {switch_ngspice.sym} 4810 -860 3 0 {name=S6 model=swmod}
C {gnd.sym} 4830 -690 0 0 {name=l22 lab=GND}
C {switch_ngspice.sym} 4320 -450 3 0 {name=S7 model=swmod}
C {gnd.sym} 4340 -280 0 0 {name=l24 lab=GND}
C {switch_ngspice.sym} 4800 -450 3 0 {name=S8 model=swmod}
C {gnd.sym} 4820 -280 0 0 {name=l26 lab=GND}
C {capa.sym} 4470 -970 2 0 {name=C4
m=1
value=80p
footprint=1206
device="ceramic capacitor"}
C {capa.sym} 4560 -530 2 0 {name=C6
m=1
value=80p
footprint=1206
device="ceramic capacitor"}
C {vsource.sym} 4660 -560 0 0 {name=vdd_sup1 value=1.8}
C {gnd.sym} 4660 -530 0 0 {name=l27 lab=GND}
C {vsource.sym} 4580 -990 0 0 {name=vdd_sup2 value=1.8}
C {gnd.sym} 4580 -960 0 0 {name=l28 lab=GND}
C {lab_pin.sym} 5010 -860 1 0 {name=l9 sig_type=std_logic lab=vcntl}
C {/home/cegrahul/Downloads/TSPC_Dff.sym} 5860 -1490 0 0 {name=xTSPC_Dff1}
C {lab_pin.sym} 6620 -1500 2 0 {name=l10 sig_type=std_logic lab=w}
C {/home/cegrahul/Desktop/SSCS/inverter.sym} -2890 1110 0 0 {name=X2}
C {/home/cegrahul/Desktop/SSCS/inverter.sym} -2800 1110 0 0 {name=X3}
C {lab_pin.sym} 5810 -1360 3 0 {name=l11 sig_type=std_logic lab=o}
C {/home/cegrahul/Downloads/TSPC_Dff.sym} 6310 -1480 0 0 {name=xTSPC_Dff2}
C {/home/cegrahul/Downloads/TSPC_Dff.sym} 6330 -1110 0 0 {name=xTSPC_Dff3}
C {/home/cegrahul/Desktop/SSCS/inverter.sym} 3650 -10020 1 0 {name=X4}
C {lab_pin.sym} 6540 -1100 2 0 {name=l15 sig_type=std_logic lab=y}
C {lab_pin.sym} 6490 -1440 2 0 {name=l16 sig_type=std_logic lab=x}
C {lab_pin.sym} 6490 -1070 2 0 {name=l17 sig_type=std_logic lab=z}
C {lab_pin.sym} 6010 -1360 3 0 {name=l19 sig_type=std_logic lab=oi}
C {lab_pin.sym} 4190 -750 3 0 {name=l23 sig_type=std_logic lab=x}
C {lab_pin.sym} 4660 -340 3 0 {name=l25 sig_type=std_logic lab=x}
C {lab_pin.sym} 4180 -340 3 0 {name=l29 sig_type=std_logic lab=w}
C {lab_pin.sym} 4670 -750 3 0 {name=l30 sig_type=std_logic lab=w}
C {xschem_sky130/sky130_fd_pr/pfet_01v8_lvt.sym} 1950 -1270 0 1 {name=M9
L=1
W=5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {res.sym} 1930 -1330 0 1 {name=R9
value=110k
footprint=1206
device=resistor
m=1}
C {xschem_sky130/sky130_fd_pr/pfet_01v8_lvt.sym} 2270 -1270 0 0 {name=M10
L=1
W=5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {res.sym} 2290 -1330 0 0 {name=R10
value=110k
footprint=1206
device=resistor
m=1}
C {vsource.sym} 2090 -1300 2 0 {name=V1 value=0.8}
C {gnd.sym} 2090 -1330 2 0 {name=l58 lab=GND}
C {xschem_sky130/sky130_fd_pr/pfet_01v8_lvt.sym} 1950 -1190 0 1 {name=M11
L=1
W=5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8_lvt.sym} 2270 -1190 0 0 {name=M12
L=1
W=5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8_lvt.sym} 1950 -1060 0 1 {name=M13
L=1
W=3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8_lvt.sym} 2270 -1060 0 0 {name=M14
L=1
W=3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8_lvt.sym} 1950 -990 0 1 {name=M15
L=1
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8_lvt.sym} 2270 -990 0 0 {name=M16
L=1
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {gnd.sym} 2290 -990 3 0 {name=l63 lab=GND}
C {gnd.sym} 1930 -990 1 0 {name=l64 lab=GND}
C {gnd.sym} 1930 -1060 1 0 {name=l73 lab=GND}
C {gnd.sym} 2290 -1060 3 0 {name=l74 lab=GND}
C {res.sym} 1930 -930 0 1 {name=R11
value=55k
footprint=1206
device=resistor
m=1}
C {res.sym} 2290 -930 0 1 {name=R12
value=55k
footprint=1206
device=resistor
m=1}
C {gnd.sym} 1930 -900 0 0 {name=l75 lab=GND}
C {gnd.sym} 2290 -900 0 0 {name=l76 lab=GND}
C {lab_pin.sym} 2290 -1240 0 0 {name=l77 sig_type=std_logic lab=d}
C {lab_pin.sym} 1970 -1060 1 0 {name=l78 sig_type=std_logic lab=y1}
C {lab_pin.sym} 1970 -1190 2 0 {name=l79 sig_type=std_logic lab=e}
C {lab_pin.sym} 1930 -1240 2 0 {name=l80 sig_type=std_logic lab=c}
C {lab_pin.sym} 2250 -1190 0 0 {name=l81 sig_type=std_logic lab=f}
C {lab_pin.sym} 2250 -1060 1 0 {name=l82 sig_type=std_logic lab=z1}
C {vsource.sym} 2060 -1480 2 0 {name=V2 value=1.8}
C {gnd.sym} 2060 -1510 2 0 {name=l87 lab=GND}
C {vsource.sym} 2340 -1130 3 0 {name=V8 value=0}
C {lab_pin.sym} 1930 -1030 0 0 {name=l90 sig_type=std_logic lab=w1}
C {lab_pin.sym} 2290 -1030 2 0 {name=l91 sig_type=std_logic lab=x1}
C {vsource.sym} 1900 -1120 1 0 {name=V9 value=0}
C {vsource.sym} 2260 -1090 3 0 {name=V10 value=0}
C {lab_pin.sym} 2290 -1220 0 0 {name=l94 sig_type=std_logic lab=dd}
C {lab_pin.sym} 1930 -1220 2 0 {name=l95 sig_type=std_logic lab=cc}
C {vsource.sym} 2260 -1160 1 0 {name=V5 value=0}
C {vsource.sym} 1900 -1160 1 0 {name=V6 value=0}
C {lab_pin.sym} 1930 -1020 0 0 {name=l108 sig_type=std_logic lab=ww}
C {lab_pin.sym} 2290 -1020 2 0 {name=l109 sig_type=std_logic lab=xx}
C {vsource.sym} 1180 -1080 3 0 {name=V20 value=0}
C {lab_pin.sym} 1210 -1080 2 0 {name=l40 sig_type=std_logic lab=c}
C {lab_pin.sym} 1150 -1060 2 0 {name=l41 sig_type=std_logic lab=d}
C {/home/cegrahul/Downloads/wienbridge1.sym} 1000 -1070 0 0 {name=x10}
C {lab_pin.sym} 1030 -1080 0 0 {name=l47 sig_type=std_logic lab=w}
C {lab_pin.sym} 1030 -1060 0 0 {name=l50 sig_type=std_logic lab=x}
C {/home/cegrahul/Desktop/ro_lvt.sym} 5640 -1360 0 0 {name=x1}
C {lab_pin.sym} 1110 -1280 0 1 {name=l36 sig_type=std_logic lab=c}
C {lab_pin.sym} 1110 -1300 0 1 {name=l39 sig_type=std_logic lab=d}
C {lab_pin.sym} 400 -1150 0 0 {name=l46 sig_type=std_logic lab=w1}
C {lab_pin.sym} 400 -1170 0 0 {name=l48 sig_type=std_logic lab=x1}
C {lab_pin.sym} 860 -1270 2 0 {name=l56 sig_type=std_logic lab=e}
C {lab_pin.sym} 860 -1290 2 0 {name=l49 sig_type=std_logic lab=f}
C {lab_pin.sym} 870 -960 2 0 {name=l53 sig_type=std_logic lab=cc}
C {lab_pin.sym} 870 -980 2 0 {name=l54 sig_type=std_logic lab=dd}
C {lab_pin.sym} 870 -1000 2 0 {name=l55 sig_type=std_logic lab=c}
C {lab_pin.sym} 870 -940 2 0 {name=l57 sig_type=std_logic lab=d}
C {lab_pin.sym} 1050 -780 2 0 {name=l65 sig_type=std_logic lab=w1}
C {lab_pin.sym} 1050 -800 2 0 {name=l66 sig_type=std_logic lab=x1}
C {lab_pin.sym} 1050 -820 2 0 {name=l67 sig_type=std_logic lab=ww}
C {lab_pin.sym} 1050 -760 2 0 {name=l68 sig_type=std_logic lab=xx}
C {lab_pin.sym} 700 -1150 2 0 {name=l69 sig_type=std_logic lab=y1}
C {lab_pin.sym} 700 -1170 2 0 {name=l70 sig_type=std_logic lab=z1}
C {/home/cegrahul/Downloads/opampp.sym} 1160 -1290 0 1 {name=x8}
C {/home/cegrahul/Downloads/opampn.sym} 550 -1160 0 0 {name=x9}
C {/home/cegrahul/Desktop/SSCS/chopper.sym} 710 -1280 0 0 {name=x11}
C {/home/cegrahul/Desktop/SSCS/chopper.sym} 720 -970 0 0 {name=x12}
C {/home/cegrahul/Desktop/SSCS/chopper.sym} 900 -790 0 0 {name=x13}
C {lab_pin.sym} 560 -1290 0 0 {name=l1 sig_type=std_logic lab=y}
C {lab_pin.sym} 560 -1310 0 0 {name=l2 sig_type=std_logic lab=z}
C {lab_pin.sym} 570 -980 0 0 {name=l3 sig_type=std_logic lab=y}
C {lab_pin.sym} 570 -1000 0 0 {name=l4 sig_type=std_logic lab=z}
C {lab_pin.sym} 750 -800 0 0 {name=l5 sig_type=std_logic lab=y}
C {lab_pin.sym} 750 -820 0 0 {name=l6 sig_type=std_logic lab=z}
