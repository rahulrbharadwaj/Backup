v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
T {BUFFER fo VCO} 4160 -1580 0 0 0.4 0.4 {}
T {INVERTER for CLK inversion} 5860 -1480 0 0 0.4 0.4 {}
T {For Dividing frequency by 2} 4510 -2750 0 0 0.4 0.4 {}
T {For Getting In-phase and In-phase-bar} 7150 -2800 0 0 0.4 0.4 {}
T {For Getting Quadrature-phase and Quadrature-phase-bar} 6980 -1370 0 0 0.4 0.4 {}
T {Supply is applied as Pulse to aid convergence} -240 -1760 0 0 0.4 0.4 {}
T {Control voltage for VCO} 190 -1550 0 0 0.4 0.4 {}
N 690 -1430 690 -1360 { lab=GND}
N 690 -1540 690 -1490 { lab=#net1}
N 690 -1710 690 -1600 { lab=#net2}
N 690 -1740 710 -1740 { lab=VDD}
N 710 -1970 710 -1740 { lab=VDD}
N 690 -1840 710 -1840 { lab=VDD}
N 600 -1740 650 -1740 { lab=Fvco}
N 600 -1740 600 -1460 { lab=Fvco}
N 600 -1460 650 -1460 { lab=Fvco}
N 600 -1570 650 -1570 { lab=Fvco}
N 690 -1970 690 -1870 { lab=VDD}
N 1010 -1430 1010 -1360 { lab=GND}
N 1010 -1540 1010 -1490 { lab=#net3}
N 1010 -1710 1010 -1600 { lab=#net4}
N 1010 -1740 1030 -1740 { lab=VDD}
N 1030 -1970 1030 -1740 { lab=VDD}
N 1010 -1840 1030 -1840 { lab=VDD}
N 920 -1740 970 -1740 { lab=#net2}
N 920 -1740 920 -1460 { lab=#net2}
N 920 -1460 970 -1460 { lab=#net2}
N 920 -1570 970 -1570 { lab=#net2}
N 1010 -1970 1010 -1870 { lab=VDD}
N 1320 -1430 1320 -1360 { lab=GND}
N 1320 -1540 1320 -1490 { lab=#net5}
N 1320 -1710 1320 -1600 { lab=#net6}
N 1320 -1740 1340 -1740 { lab=VDD}
N 1340 -1970 1340 -1740 { lab=VDD}
N 1320 -1840 1340 -1840 { lab=VDD}
N 1230 -1740 1280 -1740 { lab=#net4}
N 1230 -1740 1230 -1460 { lab=#net4}
N 1230 -1460 1280 -1460 { lab=#net4}
N 1230 -1570 1280 -1570 { lab=#net4}
N 1320 -1970 1320 -1870 { lab=VDD}
N 1710 -1430 1710 -1360 { lab=GND}
N 1710 -1540 1710 -1490 { lab=#net7}
N 1710 -1710 1710 -1600 { lab=#net8}
N 1710 -1740 1730 -1740 { lab=VDD}
N 1730 -1970 1730 -1740 { lab=VDD}
N 1710 -1840 1730 -1840 { lab=VDD}
N 1620 -1740 1670 -1740 { lab=#net6}
N 1620 -1740 1620 -1460 { lab=#net6}
N 1620 -1460 1670 -1460 { lab=#net6}
N 1620 -1570 1670 -1570 { lab=#net6}
N 1710 -1970 1710 -1870 { lab=VDD}
N 2030 -1430 2030 -1360 { lab=GND}
N 2030 -1540 2030 -1490 { lab=#net9}
N 2030 -1710 2030 -1600 { lab=#net10}
N 2030 -1740 2050 -1740 { lab=VDD}
N 2050 -1970 2050 -1740 { lab=VDD}
N 2030 -1840 2050 -1840 { lab=VDD}
N 1940 -1740 1990 -1740 { lab=#net8}
N 1940 -1740 1940 -1460 { lab=#net8}
N 1940 -1460 1990 -1460 { lab=#net8}
N 1940 -1570 1990 -1570 { lab=#net8}
N 2030 -1970 2030 -1870 { lab=VDD}
N 2340 -1430 2340 -1360 { lab=GND}
N 2340 -1540 2340 -1490 { lab=#net11}
N 2340 -1710 2340 -1600 { lab=#net12}
N 2340 -1740 2360 -1740 { lab=VDD}
N 2360 -1970 2360 -1740 { lab=VDD}
N 2340 -1840 2360 -1840 { lab=VDD}
N 2250 -1740 2300 -1740 { lab=#net10}
N 2250 -1740 2250 -1460 { lab=#net10}
N 2250 -1460 2300 -1460 { lab=#net10}
N 2250 -1570 2300 -1570 { lab=#net10}
N 2340 -1970 2340 -1870 { lab=VDD}
N 2690 -1440 2690 -1370 { lab=GND}
N 2690 -1550 2690 -1500 { lab=#net13}
N 2690 -1720 2690 -1610 { lab=#net14}
N 2690 -1750 2710 -1750 { lab=VDD}
N 2710 -1980 2710 -1750 { lab=VDD}
N 2690 -1850 2710 -1850 { lab=VDD}
N 2600 -1750 2650 -1750 { lab=#net12}
N 2600 -1750 2600 -1470 { lab=#net12}
N 2600 -1470 2650 -1470 { lab=#net12}
N 2600 -1580 2650 -1580 { lab=#net12}
N 2690 -1980 2690 -1880 { lab=VDD}
N 3010 -1440 3010 -1370 { lab=GND}
N 3010 -1550 3010 -1500 { lab=#net15}
N 3010 -1720 3010 -1610 { lab=#net16}
N 3010 -1750 3030 -1750 { lab=VDD}
N 3030 -1980 3030 -1750 { lab=VDD}
N 3010 -1850 3030 -1850 { lab=VDD}
N 2920 -1750 2970 -1750 { lab=#net14}
N 2920 -1750 2920 -1470 { lab=#net14}
N 2920 -1470 2970 -1470 { lab=#net14}
N 2920 -1580 2970 -1580 { lab=#net14}
N 3010 -1980 3010 -1880 { lab=VDD}
N 3320 -1440 3320 -1370 { lab=GND}
N 3320 -1550 3320 -1500 { lab=#net17}
N 3320 -1720 3320 -1610 { lab=Fvco}
N 3320 -1750 3340 -1750 { lab=VDD}
N 3340 -1980 3340 -1750 { lab=VDD}
N 3320 -1850 3340 -1850 { lab=VDD}
N 3230 -1750 3280 -1750 { lab=#net16}
N 3230 -1750 3230 -1470 { lab=#net16}
N 3230 -1470 3280 -1470 { lab=#net16}
N 3230 -1580 3280 -1580 { lab=#net16}
N 3320 -1980 3320 -1880 { lab=VDD}
N 690 -1970 710 -1970 { lab=VDD}
N 710 -1970 1010 -1970 { lab=VDD}
N 1010 -1970 1030 -1970 { lab=VDD}
N 1030 -1970 1320 -1970 { lab=VDD}
N 1320 -1970 1340 -1970 { lab=VDD}
N 1340 -1970 1710 -1970 { lab=VDD}
N 1710 -1970 1730 -1970 { lab=VDD}
N 1730 -1970 2030 -1970 { lab=VDD}
N 2050 -1970 2340 -1970 { lab=VDD}
N 2340 -1970 2360 -1970 { lab=VDD}
N 2360 -1970 2690 -1980 { lab=VDD}
N 2690 -1980 2710 -1980 { lab=VDD}
N 2710 -1980 3010 -1980 { lab=VDD}
N 3010 -1980 3030 -1980 { lab=VDD}
N 3030 -1980 3320 -1980 { lab=VDD}
N 3320 -1980 3340 -1980 { lab=VDD}
N 550 -1840 650 -1840 { lab=vctrl}
N 600 -1910 600 -1840 { lab=vctrl}
N 600 -1910 3250 -1910 { lab=vctrl}
N 3250 -1910 3250 -1850 { lab=vctrl}
N 3250 -1850 3280 -1850 { lab=vctrl}
N 920 -1840 970 -1840 { lab=vctrl}
N 920 -1910 920 -1840 { lab=vctrl}
N 1240 -1840 1280 -1840 { lab=vctrl}
N 1240 -1910 1240 -1840 { lab=vctrl}
N 1640 -1840 1670 -1840 { lab=vctrl}
N 1640 -1910 1640 -1840 { lab=vctrl}
N 1950 -1840 1990 -1840 { lab=vctrl}
N 1950 -1910 1950 -1840 { lab=vctrl}
N 2260 -1840 2300 -1840 { lab=vctrl}
N 2260 -1910 2260 -1840 { lab=vctrl}
N 2610 -1850 2650 -1850 { lab=vctrl}
N 2610 -1910 2610 -1850 { lab=vctrl}
N 2930 -1850 2970 -1850 { lab=vctrl}
N 2930 -1910 2930 -1850 { lab=vctrl}
N 690 -1650 920 -1650 { lab=#net2}
N 1010 -1650 1230 -1650 { lab=#net4}
N 1320 -1650 1620 -1650 { lab=#net6}
N 1710 -1650 1940 -1650 { lab=#net8}
N 2030 -1650 2250 -1650 { lab=#net10}
N 2340 -1650 2600 -1650 { lab=#net12}
N 2690 -1650 2920 -1650 { lab=#net14}
N 3010 -1650 3230 -1650 { lab=#net16}
N 3320 -1650 3480 -1650 { lab=Fvco}
N 3480 -1650 3480 -1270 { lab=Fvco}
N 530 -1270 3480 -1270 { lab=Fvco}
N 530 -1650 530 -1270 { lab=Fvco}
N 530 -1650 600 -1650 { lab=Fvco}
N 690 -1810 690 -1770 { lab=#net18}
N 1010 -1810 1010 -1770 { lab=#net18}
N 1320 -1810 1320 -1770 { lab=#net18}
N 1710 -1810 1710 -1770 { lab=#net18}
N 2030 -1810 2030 -1770 { lab=#net18}
N 2340 -1810 2340 -1770 { lab=#net18}
N 2690 -1820 2690 -1780 { lab=#net18}
N 3010 -1820 3010 -1780 { lab=#net18}
N 3320 -1820 3320 -1780 { lab=#net18}
N 2030 -1970 2050 -1970 { lab=VDD}
N 690 -1790 1010 -1790 { lab=#net18}
N 1010 -1790 1320 -1790 { lab=#net18}
N 1320 -1790 1710 -1790 { lab=#net18}
N 1710 -1790 2030 -1790 { lab=#net18}
N 2030 -1790 2340 -1790 { lab=#net18}
N 2340 -1790 2690 -1790 { lab=#net18}
N 2690 -1790 3010 -1790 { lab=#net18}
N 3010 -1790 3320 -1790 { lab=#net18}
N 4070 -2570 4070 -2500 { lab=VDD}
N 5610 -2570 5610 -2410 { lab=VDD}
N 4370 -2570 4370 -2500 { lab=VDD}
N 4880 -2570 4880 -2500 { lab=VDD}
N 5240 -2570 5240 -2410 { lab=VDD}
N 4070 -2100 4070 -1980 { lab=GND}
N 5610 -2190 5610 -1980 { lab=GND}
N 4880 -2100 4880 -1980 { lab=GND}
N 5240 -2190 5240 -1980 { lab=GND}
N 3830 -2570 4070 -2570 { lab=VDD}
N 3840 -1980 4070 -1980 { lab=GND}
N 4070 -2470 4090 -2470 { lab=VDD}
N 4090 -2500 4090 -2470 { lab=VDD}
N 4070 -2500 4090 -2500 { lab=VDD}
N 4370 -2470 4390 -2470 { lab=VDD}
N 4390 -2500 4390 -2470 { lab=VDD}
N 4370 -2500 4390 -2500 { lab=VDD}
N 4880 -2470 4900 -2470 { lab=VDD}
N 4900 -2500 4900 -2470 { lab=VDD}
N 4880 -2500 4900 -2500 { lab=VDD}
N 5240 -2380 5260 -2380 { lab=VDD}
N 5260 -2410 5260 -2380 { lab=VDD}
N 5240 -2410 5260 -2410 { lab=VDD}
N 5610 -2380 5630 -2380 { lab=VDD}
N 5630 -2410 5630 -2380 { lab=VDD}
N 5610 -2410 5630 -2410 { lab=VDD}
N 3810 -2220 3960 -2220 { lab=#net19}
N 3960 -2470 3960 -2220 { lab=#net19}
N 3960 -2470 4030 -2470 { lab=#net19}
N 3960 -2130 4030 -2130 { lab=#net19}
N 3960 -2220 3960 -2130 { lab=#net19}
N 4070 -2440 4070 -2340 { lab=#net20}
N 4070 -2280 4070 -2160 { lab=#net21}
N 4880 -2440 4880 -2340 { lab=#net22}
N 4880 -2280 4880 -2160 { lab=#net23}
N 5240 -2350 5240 -2250 { lab=FvcoBy2}
N 5170 -2380 5200 -2380 { lab=#net22}
N 5170 -2380 5170 -2220 { lab=#net22}
N 5170 -2220 5200 -2220 { lab=#net22}
N 5610 -2350 5610 -2250 { lab=#net19}
N 5550 -2380 5570 -2380 { lab=FvcoBy2}
N 5550 -2380 5550 -2220 { lab=FvcoBy2}
N 5550 -2220 5570 -2220 { lab=FvcoBy2}
N 5240 -2300 5550 -2300 { lab=FvcoBy2}
N 4300 -2470 4330 -2470 { lab=FvcoBUF}
N 4300 -2470 4300 -2130 { lab=FvcoBUF}
N 4810 -2470 4840 -2470 { lab=#net24}
N 4810 -2470 4810 -2130 { lab=#net24}
N 4810 -2130 4840 -2130 { lab=#net24}
N 3810 -2310 4030 -2310 { lab=FvcoBUF}
N 4070 -2230 4240 -2230 { lab=#net21}
N 4880 -2390 5110 -2390 { lab=#net22}
N 5110 -2390 5110 -2300 { lab=#net22}
N 5110 -2300 5170 -2300 { lab=#net22}
N 4790 -2310 4840 -2310 { lab=FvcoBUF}
N 4070 -2570 4370 -2570 { lab=VDD}
N 4880 -2570 5240 -2570 { lab=VDD}
N 5240 -2570 5610 -2570 { lab=VDD}
N 4070 -1980 4370 -1980 { lab=GND}
N 4880 -1980 5240 -1980 { lab=GND}
N 5240 -1980 5610 -1980 { lab=GND}
N 4370 -2200 4370 -2090 { lab=#net25}
N 4370 -2030 4370 -1980 { lab=GND}
N 4370 -2310 4370 -2260 { lab=#net24}
N 4370 -2440 4370 -2370 { lab=#net26}
N 4300 -2130 4300 -2060 { lab=FvcoBUF}
N 4300 -2060 4330 -2060 { lab=FvcoBUF}
N 4240 -2230 4330 -2230 { lab=#net21}
N 4320 -2340 4330 -2340 { lab=VRESET}
N 4320 -2390 4320 -2340 { lab=VRESET}
N 4600 -2200 4600 -1980 { lab=GND}
N 4530 -2230 4560 -2230 { lab=VRESET}
N 4530 -2390 4530 -2230 { lab=VRESET}
N 3810 -2390 4320 -2390 { lab=VRESET}
N 4320 -2390 4530 -2390 { lab=VRESET}
N 4370 -2280 4670 -2280 { lab=#net24}
N 4600 -2280 4600 -2260 { lab=#net24}
N 4370 -1980 4600 -1980 { lab=GND}
N 4600 -1980 4880 -1980 { lab=GND}
N 4360 -2570 4880 -2570 { lab=VDD}
N 4670 -2280 4810 -2280 { lab=#net24}
N 4710 -2310 4790 -2310 { lab=FvcoBUF}
N 6660 -2570 6660 -2500 { lab=VDD}
N 8200 -2570 8200 -2410 { lab=VDD}
N 6960 -2570 6960 -2500 { lab=VDD}
N 7470 -2570 7470 -2500 { lab=VDD}
N 7830 -2570 7830 -2410 { lab=VDD}
N 6660 -2100 6660 -1980 { lab=GND}
N 8200 -2190 8200 -1980 { lab=GND}
N 7470 -2100 7470 -1980 { lab=GND}
N 7830 -2190 7830 -1980 { lab=GND}
N 6420 -2570 6660 -2570 { lab=VDD}
N 6430 -1980 6660 -1980 { lab=GND}
N 6660 -2470 6680 -2470 { lab=VDD}
N 6680 -2500 6680 -2470 { lab=VDD}
N 6660 -2500 6680 -2500 { lab=VDD}
N 6960 -2470 6980 -2470 { lab=VDD}
N 6980 -2500 6980 -2470 { lab=VDD}
N 6960 -2500 6980 -2500 { lab=VDD}
N 7470 -2470 7490 -2470 { lab=VDD}
N 7490 -2500 7490 -2470 { lab=VDD}
N 7470 -2500 7490 -2500 { lab=VDD}
N 7830 -2380 7850 -2380 { lab=VDD}
N 7850 -2410 7850 -2380 { lab=VDD}
N 7830 -2410 7850 -2410 { lab=VDD}
N 8200 -2380 8220 -2380 { lab=VDD}
N 8220 -2410 8220 -2380 { lab=VDD}
N 8200 -2410 8220 -2410 { lab=VDD}
N 6400 -2220 6550 -2220 { lab=FvcoBy4_IPH_bar}
N 6550 -2470 6550 -2220 { lab=FvcoBy4_IPH_bar}
N 6550 -2470 6620 -2470 { lab=FvcoBy4_IPH_bar}
N 6550 -2130 6620 -2130 { lab=FvcoBy4_IPH_bar}
N 6550 -2220 6550 -2130 { lab=FvcoBy4_IPH_bar}
N 6660 -2440 6660 -2340 { lab=#net27}
N 6660 -2280 6660 -2160 { lab=#net28}
N 7470 -2440 7470 -2340 { lab=#net29}
N 7470 -2280 7470 -2160 { lab=#net30}
N 7830 -2350 7830 -2250 { lab=FvcoBy4_IPH}
N 7760 -2380 7790 -2380 { lab=#net29}
N 7760 -2380 7760 -2220 { lab=#net29}
N 7760 -2220 7790 -2220 { lab=#net29}
N 8200 -2350 8200 -2250 { lab=FvcoBy4_IPH_bar}
N 8140 -2380 8160 -2380 { lab=FvcoBy4_IPH}
N 8140 -2380 8140 -2220 { lab=FvcoBy4_IPH}
N 8140 -2220 8160 -2220 { lab=FvcoBy4_IPH}
N 7830 -2300 8140 -2300 { lab=FvcoBy4_IPH}
N 6890 -2470 6920 -2470 { lab=FvcoBy2}
N 6890 -2470 6890 -2130 { lab=FvcoBy2}
N 7400 -2470 7430 -2470 { lab=#net31}
N 7400 -2470 7400 -2130 { lab=#net31}
N 7400 -2130 7430 -2130 { lab=#net31}
N 6400 -2310 6620 -2310 { lab=FvcoBy2}
N 6660 -2230 6830 -2230 { lab=#net28}
N 7470 -2390 7700 -2390 { lab=#net29}
N 7700 -2390 7700 -2300 { lab=#net29}
N 7700 -2300 7760 -2300 { lab=#net29}
N 7380 -2310 7430 -2310 { lab=FvcoBy2}
N 6660 -2570 6960 -2570 { lab=VDD}
N 7470 -2570 7830 -2570 { lab=VDD}
N 7830 -2570 8200 -2570 { lab=VDD}
N 6660 -1980 6960 -1980 { lab=GND}
N 7470 -1980 7830 -1980 { lab=GND}
N 7830 -1980 8200 -1980 { lab=GND}
N 6960 -2200 6960 -2090 { lab=#net32}
N 6960 -2030 6960 -1980 { lab=GND}
N 6960 -2310 6960 -2260 { lab=#net31}
N 6960 -2440 6960 -2370 { lab=#net33}
N 6890 -2130 6890 -2060 { lab=FvcoBy2}
N 6890 -2060 6920 -2060 { lab=FvcoBy2}
N 6830 -2230 6920 -2230 { lab=#net28}
N 6910 -2340 6920 -2340 { lab=VRESET}
N 6910 -2390 6910 -2340 { lab=VRESET}
N 7190 -2200 7190 -1980 { lab=GND}
N 7120 -2230 7150 -2230 { lab=VRESET}
N 7120 -2390 7120 -2230 { lab=VRESET}
N 6400 -2390 6910 -2390 { lab=VRESET}
N 6910 -2390 7120 -2390 { lab=VRESET}
N 6960 -2280 7260 -2280 { lab=#net31}
N 7190 -2280 7190 -2260 { lab=#net31}
N 6960 -1980 7190 -1980 { lab=GND}
N 7190 -1980 7470 -1980 { lab=GND}
N 6950 -2570 7470 -2570 { lab=VDD}
N 7260 -2280 7400 -2280 { lab=#net31}
N 7300 -2310 7380 -2310 { lab=FvcoBy2}
N 6660 -1090 6660 -1020 { lab=VDD}
N 8200 -1090 8200 -930 { lab=VDD}
N 6960 -1090 6960 -1020 { lab=VDD}
N 7470 -1090 7470 -1020 { lab=VDD}
N 7830 -1090 7830 -930 { lab=VDD}
N 6660 -620 6660 -500 { lab=GND}
N 8200 -710 8200 -500 { lab=GND}
N 7470 -620 7470 -500 { lab=GND}
N 7830 -710 7830 -500 { lab=GND}
N 6420 -1090 6660 -1090 { lab=VDD}
N 6430 -500 6660 -500 { lab=GND}
N 6660 -990 6680 -990 { lab=VDD}
N 6680 -1020 6680 -990 { lab=VDD}
N 6660 -1020 6680 -1020 { lab=VDD}
N 6960 -990 6980 -990 { lab=VDD}
N 6980 -1020 6980 -990 { lab=VDD}
N 6960 -1020 6980 -1020 { lab=VDD}
N 7470 -990 7490 -990 { lab=VDD}
N 7490 -1020 7490 -990 { lab=VDD}
N 7470 -1020 7490 -1020 { lab=VDD}
N 7830 -900 7850 -900 { lab=VDD}
N 7850 -930 7850 -900 { lab=VDD}
N 7830 -930 7850 -930 { lab=VDD}
N 8200 -900 8220 -900 { lab=VDD}
N 8220 -930 8220 -900 { lab=VDD}
N 8200 -930 8220 -930 { lab=VDD}
N 6400 -740 6550 -740 { lab=FvcoBy4_QPH_bar}
N 6550 -990 6550 -740 { lab=FvcoBy4_QPH_bar}
N 6550 -990 6620 -990 { lab=FvcoBy4_QPH_bar}
N 6550 -650 6620 -650 { lab=FvcoBy4_QPH_bar}
N 6550 -740 6550 -650 { lab=FvcoBy4_QPH_bar}
N 6660 -960 6660 -860 { lab=#net34}
N 6660 -800 6660 -680 { lab=#net35}
N 7470 -960 7470 -860 { lab=#net36}
N 7470 -800 7470 -680 { lab=#net37}
N 7830 -870 7830 -770 { lab=FvcoBy4_QPH}
N 7760 -900 7790 -900 { lab=#net36}
N 7760 -900 7760 -740 { lab=#net36}
N 7760 -740 7790 -740 { lab=#net36}
N 8200 -870 8200 -770 { lab=FvcoBy4_QPH_bar}
N 8140 -900 8160 -900 { lab=FvcoBy4_QPH}
N 8140 -900 8140 -740 { lab=FvcoBy4_QPH}
N 8140 -740 8160 -740 { lab=FvcoBy4_QPH}
N 7830 -820 8140 -820 { lab=FvcoBy4_QPH}
N 6890 -990 6920 -990 { lab=FvcoBy2_bar}
N 6890 -990 6890 -650 { lab=FvcoBy2_bar}
N 7400 -990 7430 -990 { lab=#net38}
N 7400 -990 7400 -650 { lab=#net38}
N 7400 -650 7430 -650 { lab=#net38}
N 6400 -830 6620 -830 { lab=FvcoBy2_bar}
N 6660 -750 6830 -750 { lab=#net35}
N 7470 -910 7700 -910 { lab=#net36}
N 7700 -910 7700 -820 { lab=#net36}
N 7700 -820 7760 -820 { lab=#net36}
N 7380 -830 7430 -830 { lab=FvcoBy2_bar}
N 6660 -1090 6960 -1090 { lab=VDD}
N 7470 -1090 7830 -1090 { lab=VDD}
N 7830 -1090 8200 -1090 { lab=VDD}
N 6660 -500 6960 -500 { lab=GND}
N 7470 -500 7830 -500 { lab=GND}
N 7830 -500 8200 -500 { lab=GND}
N 6960 -720 6960 -610 { lab=#net39}
N 6960 -550 6960 -500 { lab=GND}
N 6960 -830 6960 -780 { lab=#net38}
N 6960 -960 6960 -890 { lab=#net40}
N 6890 -650 6890 -580 { lab=FvcoBy2_bar}
N 6890 -580 6920 -580 { lab=FvcoBy2_bar}
N 6830 -750 6920 -750 { lab=#net35}
N 6910 -860 6920 -860 { lab=VRESET}
N 6910 -910 6910 -860 { lab=VRESET}
N 7190 -720 7190 -500 { lab=GND}
N 7120 -750 7150 -750 { lab=VRESET}
N 7120 -910 7120 -750 { lab=VRESET}
N 6400 -910 6910 -910 { lab=VRESET}
N 6910 -910 7120 -910 { lab=VRESET}
N 6960 -800 7260 -800 { lab=#net38}
N 7190 -800 7190 -780 { lab=#net38}
N 6960 -500 7190 -500 { lab=GND}
N 7190 -500 7470 -500 { lab=GND}
N 6950 -1090 7470 -1090 { lab=VDD}
N 7260 -800 7400 -800 { lab=#net38}
N 7300 -830 7380 -830 { lab=FvcoBy2_bar}
N 5990 -1360 6010 -1360 { lab=VDD}
N 6010 -1390 6010 -1360 { lab=VDD}
N 5990 -1390 6010 -1390 { lab=VDD}
N 5990 -1330 5990 -1230 { lab=FvcoBy2_bar}
N 5930 -1360 5950 -1360 { lab=FvcoBy2}
N 5930 -1360 5930 -1200 { lab=FvcoBy2}
N 5930 -1200 5950 -1200 { lab=FvcoBy2}
N 5720 -2650 5720 -2320 { lab=#net19}
N 3650 -2650 5720 -2650 { lab=#net19}
N 3650 -2650 3650 -2220 { lab=#net19}
N 3650 -2220 3810 -2220 { lab=#net19}
N 5610 -2320 5720 -2320 { lab=#net19}
N 6240 -2220 6400 -2220 { lab=FvcoBy4_IPH_bar}
N 6240 -2650 6240 -2220 { lab=FvcoBy4_IPH_bar}
N 6240 -2650 8340 -2650 { lab=FvcoBy4_IPH_bar}
N 8340 -2650 8340 -2300 { lab=FvcoBy4_IPH_bar}
N 8200 -2300 8340 -2300 { lab=FvcoBy4_IPH_bar}
N 8200 -820 8330 -820 { lab=FvcoBy4_QPH_bar}
N 8330 -1200 8330 -820 { lab=FvcoBy4_QPH_bar}
N 6290 -1200 8330 -1200 { lab=FvcoBy4_QPH_bar}
N 6290 -1200 6290 -740 { lab=FvcoBy4_QPH_bar}
N 6290 -740 6400 -740 { lab=FvcoBy4_QPH_bar}
N 4110 -1460 4130 -1460 { lab=VDD}
N 4130 -1490 4130 -1460 { lab=VDD}
N 4110 -1490 4130 -1490 { lab=VDD}
N 4110 -1430 4110 -1330 { lab=#net41}
N 4050 -1460 4070 -1460 { lab=Fvco}
N 4050 -1460 4050 -1300 { lab=Fvco}
N 4050 -1300 4070 -1300 { lab=Fvco}
N 4400 -1460 4420 -1460 { lab=VDD}
N 4420 -1490 4420 -1460 { lab=VDD}
N 4400 -1490 4420 -1490 { lab=VDD}
N 4400 -1430 4400 -1330 { lab=FvcoBUF}
N 4340 -1460 4360 -1460 { lab=#net41}
N 4340 -1460 4340 -1300 { lab=#net41}
N 4340 -1300 4360 -1300 { lab=#net41}
N 4110 -1380 4340 -1380 { lab=#net41}
N -980 -1180 -930 -1180 { lab=FvcoBy4_IPH}
N -930 -1180 -850 -1180 { lab=FvcoBy4_IPH}
N -840 -1250 -840 -1180 { lab=FvcoBy4_IPH}
N -850 -1180 -840 -1180 { lab=FvcoBy4_IPH}
N -820 -1250 -820 -1120 { lab=GND}
N -500 -1180 -450 -1180 { lab=FvcoBy4_IPH_bar}
N -450 -1180 -370 -1180 { lab=FvcoBy4_IPH_bar}
N -360 -1250 -360 -1180 { lab=FvcoBy4_IPH_bar}
N -370 -1180 -360 -1180 { lab=FvcoBy4_IPH_bar}
N -340 -1250 -340 -1120 { lab=GND}
N -990 -770 -940 -770 { lab=FvcoBy4_IPH_bar}
N -940 -770 -860 -770 { lab=FvcoBy4_IPH_bar}
N -850 -840 -850 -770 { lab=FvcoBy4_IPH_bar}
N -860 -770 -850 -770 { lab=FvcoBy4_IPH_bar}
N -830 -840 -830 -710 { lab=GND}
N -510 -770 -460 -770 { lab=FvcoBy4_IPH}
N -460 -770 -380 -770 { lab=FvcoBy4_IPH}
N -370 -840 -370 -770 { lab=FvcoBy4_IPH}
N -380 -770 -370 -770 { lab=FvcoBy4_IPH}
N -350 -840 -350 -710 { lab=GND}
N -820 -880 -400 -880 { lab=#net42}
N -810 -1290 -380 -1290 { lab=#net43}
N -330 -1290 -320 -1290 { lab=vctrl}
N -320 -1290 -150 -1290 { lab=vctrl}
N -150 -1290 -150 -880 { lab=vctrl}
N -340 -880 -330 -880 { lab=vctrl}
N -330 -880 -150 -880 { lab=vctrl}
N -530 -1050 -510 -1050 { lab=#net44}
N -510 -1050 -510 -1020 { lab=#net44}
N -610 -1480 -590 -1480 { lab=#net45}
N -590 -1480 -590 -1450 { lab=#net45}
N -700 -1370 -700 -1290 { lab=#net43}
N -700 -1480 -700 -1430 { lab=#net45}
N -700 -1480 -600 -1480 { lab=#net45}
N -610 -1050 -610 -990 { lab=#net44}
N -610 -1050 -530 -1050 { lab=#net44}
N -610 -930 -610 -880 { lab=#net42}
N -1300 -1290 -870 -1290 { lab=#net46}
N -1300 -1290 -1300 -890 { lab=#net46}
N -1300 -880 -880 -880 { lab=#net46}
N -1300 -910 -1300 -880 { lab=#net46}
N -150 -1290 -40 -1290 { lab=vctrl}
N -890 -1180 -880 -1180 { lab=FvcoBy4_IPH}
N -460 -770 -410 -770 { lab=FvcoBy4_IPH}
N -400 -770 -390 -770 { lab=FvcoBy4_IPH}
N -2310 -1080 -2310 -1010 { lab=#net47}
N -2310 -1080 -2160 -1080 { lab=#net47}
N -2160 -1080 -2160 -1060 { lab=#net47}
N -2310 -950 -2310 -930 { lab=#net48}
N -2310 -870 -2310 -810 { lab=#net49}
N -2430 -1020 -2310 -1020 { lab=#net47}
N -2430 -960 -2430 -940 { lab=#net48}
N -2430 -940 -2310 -940 { lab=#net48}
N -2160 -1080 -1950 -1080 { lab=#net47}
N -2310 -580 -2310 -560 { lab=#net50}
N -2310 -500 -2310 -450 { lab=GND}
N -2430 -580 -2430 -560 { lab=#net50}
N -2430 -640 -2310 -640 { lab=#net49}
N -2430 -560 -2310 -560 { lab=#net50}
N -1900 -1080 -1900 -1010 { lab=#net47}
N -1900 -950 -1900 -930 { lab=#net51}
N -1900 -870 -1900 -810 { lab=#net52}
N -2020 -1020 -1900 -1020 { lab=#net47}
N -2020 -960 -2020 -940 { lab=#net51}
N -2020 -940 -1900 -940 { lab=#net51}
N -1900 -580 -1900 -560 { lab=#net53}
N -1900 -500 -1900 -450 { lab=GND}
N -2020 -580 -2020 -560 { lab=#net53}
N -2020 -640 -1900 -640 { lab=#net52}
N -2020 -560 -1900 -560 { lab=#net53}
N -1950 -1080 -1900 -1080 { lab=#net47}
N -1900 -810 -1900 -640 { lab=#net52}
N -2310 -810 -2310 -640 { lab=#net49}
N -1650 -210 -1570 -210 { lab=FvcoBy4_QPH}
N -1440 -320 -1340 -320 { lab=#net46}
N -1560 -280 -1560 -210 { lab=FvcoBy4_QPH}
N -1570 -210 -1560 -210 { lab=FvcoBy4_QPH}
N -1530 -320 -1440 -320 { lab=#net46}
N -1750 -320 -1590 -320 { lab=#net49}
N -1540 -280 -1540 -150 { lab=GND}
N -1480 -520 -1400 -520 { lab=FvcoBy4_QPH_bar}
N -1390 -590 -1390 -520 { lab=FvcoBy4_QPH_bar}
N -1400 -520 -1390 -520 { lab=FvcoBy4_QPH_bar}
N -1580 -630 -1420 -630 { lab=#net52}
N -1370 -590 -1370 -460 { lab=GND}
N -1730 -630 -1580 -630 { lab=#net52}
N -1770 -320 -1740 -320 { lab=#net49}
N -2310 -760 -2180 -760 { lab=#net49}
N -2180 -760 -2180 -320 { lab=#net49}
N -2180 -320 -1760 -320 { lab=#net49}
N -1900 -710 -1730 -710 { lab=#net52}
N -1730 -710 -1730 -630 { lab=#net52}
N -1300 -810 -1300 -320 { lab=#net46}
N -1340 -320 -1300 -320 { lab=#net46}
N -1360 -630 -1300 -630 { lab=#net46}
N -1720 -210 -1640 -210 { lab=FvcoBy4_QPH}
N -1640 -210 -1630 -210 { lab=FvcoBy4_QPH}
N -3180 -1090 -3010 -1090 { lab=#net54}
N -3120 -1090 -3120 -870 { lab=#net54}
N -3120 -810 -3120 -210 { lab=#net55}
N -3240 -210 -3030 -210 { lab=#net55}
N -3390 -1090 -3300 -1090 { lab=FvcoBy4_IPH}
N -3420 -210 -3360 -210 { lab=FvcoBy4_IPH_bar}
N -3500 -1090 -3380 -1090 { lab=FvcoBy4_IPH}
N -2950 -1090 -2910 -1090 { lab=#net56}
N -2970 -210 -2940 -210 { lab=#net57}
N -2880 -210 -2850 -210 { lab=GND}
N -2790 -210 -2760 -210 { lab=GND}
N -2850 -1090 -2840 -1090 { lab=GND}
N -2780 -1090 -2750 -1090 { lab=GND}
N -2840 -1090 -2770 -1090 { lab=GND}
N -2850 -210 -2780 -210 { lab=GND}
N -3720 -1090 -3490 -1090 { lab=FvcoBy4_IPH}
N -3650 -210 -3420 -210 { lab=FvcoBy4_IPH_bar}
N -1300 -880 -1300 -810 { lab=#net46}
N -40 -1840 -40 -1290 { lab=vctrl}
N 140 -2330 140 -2290 { lab=vctrl}
N 90 -2330 140 -2330 { lab=vctrl}
N 90 -2330 90 -2290 { lab=vctrl}
N 170 -2290 230 -2290 { lab=#net58}
N 90 -2290 110 -2290 { lab=vctrl}
N 230 -2290 440 -2290 { lab=#net58}
N 440 -2290 440 -2250 { lab=#net58}
N -40 -1840 550 -1840 { lab=vctrl}
N -40 -2290 90 -2290 { lab=vctrl}
N -40 -2290 -40 -1840 { lab=vctrl}
C {vsource.sym} 30 -1640 0 0 {name=V2 value="pwl(0.000us 0.0V,
+ 0.500us 0.0V, 0.501us 1.8V)"
}
C {gnd.sym} 30 -1610 0 0 {name=l21 lab=GND}
C {vsource.sym} 440 -2220 0 0 {name=V1 value=0.85V}
C {gnd.sym} 440 -2190 0 0 {name=l22 lab=GND}
C {code_shown.sym} 2010 -2230 0 0 {name=spice only_toplevel=true value="
.tran 1ns 100us
.save vctrl Fvco FvcoBy4_QPH FvcoBy4_IPH
"}
C {lab_pin.sym} 30 -1670 1 0 {name=l20 sig_type=std_logic lab=VDD}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} 670 -1570 0 0 {name=M28
L=4
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 670 -1840 0 0 {name=M38
L=4
W=0.55
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 670 -1740 0 0 {name=M39
L=4
W=0.55
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} 670 -1460 0 0 {name=M40
L=4
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 690 -1360 0 0 {name=l13 lab=GND}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} 990 -1570 0 0 {name=M41
L=4
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 990 -1840 0 0 {name=M42
L=4
W=0.55
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 990 -1740 0 0 {name=M43
L=4
W=0.55
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} 990 -1460 0 0 {name=M44
L=4
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 1010 -1360 0 0 {name=l14 lab=GND}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} 1300 -1570 0 0 {name=M45
L=4
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 1300 -1840 0 0 {name=M46
L=4
W=0.55
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 1300 -1740 0 0 {name=M47
L=4
W=0.55
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} 1300 -1460 0 0 {name=M48
L=4
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 1320 -1360 0 0 {name=l15 lab=GND}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} 1690 -1570 0 0 {name=M49
L=4
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 1690 -1840 0 0 {name=M50
L=4
W=0.55
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 1690 -1740 0 0 {name=M51
L=4
W=0.55
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} 1690 -1460 0 0 {name=M52
L=4
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 1710 -1360 0 0 {name=l16 lab=GND}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} 2010 -1570 0 0 {name=M53
L=4
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 2010 -1840 0 0 {name=M54
L=4
W=0.55
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 2010 -1740 0 0 {name=M55
L=4
W=0.55
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} 2010 -1460 0 0 {name=M56
L=4
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 2030 -1360 0 0 {name=l17 lab=GND}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} 2320 -1570 0 0 {name=M57
L=4
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 2320 -1840 0 0 {name=M58
L=4
W=0.55
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 2320 -1740 0 0 {name=M59
L=4
W=0.55
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} 2320 -1460 0 0 {name=M60
L=4
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 2340 -1360 0 0 {name=l18 lab=GND}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} 2670 -1580 0 0 {name=M61
L=4
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 2670 -1850 0 0 {name=M62
L=4
W=0.55
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 2670 -1750 0 0 {name=M63
L=4
W=0.55
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} 2670 -1470 0 0 {name=M64
L=4
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 2690 -1370 0 0 {name=l19 lab=GND}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} 2990 -1580 0 0 {name=M65
L=4
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 2990 -1850 0 0 {name=M66
L=4
W=0.55
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 2990 -1750 0 0 {name=M67
L=4
W=0.55
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} 2990 -1470 0 0 {name=M68
L=4
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 3010 -1370 0 0 {name=l25 lab=GND}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} 3300 -1580 0 0 {name=M69
L=4
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 3300 -1850 0 0 {name=M70
L=4
W=0.55
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 3300 -1750 0 0 {name=M71
L=4
W=0.55
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet3_01v8.sym} 3300 -1470 0 0 {name=M72
L=4
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 3320 -1370 0 0 {name=l26 lab=GND}
C {lab_pin.sym} 2350 -1970 1 0 {name=l27 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 3480 -1610 2 0 {name=l29 sig_type=std_logic lab=Fvco}
C {vsource.sym} 5470 -1570 0 0 {name=V3 value="pwl(0.000us 0.0V, 
+ 0.500us 0.0V, 0.501us 1.8V,
+ 1.500us 1.8V, 1.501us 0.0V)"
}
C {gnd.sym} 5470 -1540 0 0 {name=l4 lab=GND}
C {lab_pin.sym} 5470 -1600 2 0 {name=l5 sig_type=std_logic lab=VRESET}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 4050 -2130 0 0 {name=M1
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 4050 -2470 0 0 {name=M2
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 4050 -2310 0 0 {name=M3
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 4350 -2060 0 0 {name=M4
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 4350 -2470 0 0 {name=M5
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 4860 -2130 0 0 {name=M6
L=0.50
W=0.42
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 4860 -2470 0 0 {name=M7
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 4350 -2230 0 0 {name=M9
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 4860 -2310 0 0 {name=M11
L=0.50
W=0.42
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 5220 -2380 0 0 {name=M10
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 5220 -2220 0 0 {name=M13
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 5590 -2380 0 0 {name=M12
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 5590 -2220 0 0 {name=M15
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 3830 -2570 0 0 {name=l9 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 3840 -1980 0 0 {name=l10 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4070 -2130 2 0 {name=l11 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4370 -2060 2 0 {name=l12 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4370 -2230 2 0 {name=l23 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4880 -2130 2 0 {name=l30 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4880 -2310 2 0 {name=l31 sig_type=std_logic lab=GND}
C {lab_pin.sym} 5240 -2220 2 0 {name=l32 sig_type=std_logic lab=GND}
C {lab_pin.sym} 5610 -2220 2 0 {name=l33 sig_type=std_logic lab=GND}
C {lab_pin.sym} 4070 -2310 2 0 {name=l34 sig_type=std_logic lab=VDD}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 4350 -2340 0 0 {name=M14
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 4370 -2340 2 0 {name=l35 sig_type=std_logic lab=VDD}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 4580 -2230 0 0 {name=M16
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 4600 -2230 2 0 {name=l36 sig_type=std_logic lab=GND}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 6640 -2130 0 0 {name=M8
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 6640 -2470 0 0 {name=M17
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 6640 -2310 0 0 {name=M18
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 6940 -2060 0 0 {name=M19
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 6940 -2470 0 0 {name=M20
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 7450 -2130 0 0 {name=M21
L=0.50
W=0.42
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 7450 -2470 0 0 {name=M22
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 6940 -2230 0 0 {name=M23
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 7450 -2310 0 0 {name=M24
L=0.50
W=0.42
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 7810 -2380 0 0 {name=M25
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 7810 -2220 0 0 {name=M26
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 8180 -2380 0 0 {name=M27
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 8180 -2220 0 0 {name=M29
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 6420 -2570 0 0 {name=l37 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 6430 -1980 0 0 {name=l38 sig_type=std_logic lab=GND}
C {lab_pin.sym} 6660 -2130 2 0 {name=l39 sig_type=std_logic lab=GND}
C {lab_pin.sym} 6960 -2060 2 0 {name=l40 sig_type=std_logic lab=GND}
C {lab_pin.sym} 6960 -2230 2 0 {name=l41 sig_type=std_logic lab=GND}
C {lab_pin.sym} 7470 -2130 2 0 {name=l42 sig_type=std_logic lab=GND}
C {lab_pin.sym} 7470 -2310 2 0 {name=l43 sig_type=std_logic lab=GND}
C {lab_pin.sym} 7830 -2220 2 0 {name=l44 sig_type=std_logic lab=GND}
C {lab_pin.sym} 8200 -2220 2 0 {name=l45 sig_type=std_logic lab=GND}
C {lab_pin.sym} 6660 -2310 2 0 {name=l46 sig_type=std_logic lab=VDD}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 6940 -2340 0 0 {name=M30
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 6960 -2340 2 0 {name=l47 sig_type=std_logic lab=VDD}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 7170 -2230 0 0 {name=M31
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 7190 -2230 2 0 {name=l48 sig_type=std_logic lab=GND}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 6640 -650 0 0 {name=M32
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 6640 -990 0 0 {name=M33
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 6640 -830 0 0 {name=M34
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 6940 -580 0 0 {name=M35
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 6940 -990 0 0 {name=M36
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 7450 -650 0 0 {name=M37
L=0.50
W=0.42
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 7450 -990 0 0 {name=M73
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 6940 -750 0 0 {name=M74
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 7450 -830 0 0 {name=M75
L=0.50
W=0.42
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 7810 -900 0 0 {name=M76
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 7810 -740 0 0 {name=M77
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 8180 -900 0 0 {name=M78
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 8180 -740 0 0 {name=M79
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 6420 -1090 0 0 {name=l49 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 6430 -500 0 0 {name=l50 sig_type=std_logic lab=GND}
C {lab_pin.sym} 6660 -650 2 0 {name=l51 sig_type=std_logic lab=GND}
C {lab_pin.sym} 6960 -580 2 0 {name=l52 sig_type=std_logic lab=GND}
C {lab_pin.sym} 6960 -750 2 0 {name=l53 sig_type=std_logic lab=GND}
C {lab_pin.sym} 7470 -650 2 0 {name=l54 sig_type=std_logic lab=GND}
C {lab_pin.sym} 7470 -830 2 0 {name=l55 sig_type=std_logic lab=GND}
C {lab_pin.sym} 7830 -740 2 0 {name=l56 sig_type=std_logic lab=GND}
C {lab_pin.sym} 8200 -740 2 0 {name=l57 sig_type=std_logic lab=GND}
C {lab_pin.sym} 6660 -830 2 0 {name=l58 sig_type=std_logic lab=VDD}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 6940 -860 0 0 {name=M80
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 6960 -860 2 0 {name=l59 sig_type=std_logic lab=VDD}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 7170 -750 0 0 {name=M81
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 7190 -750 2 0 {name=l60 sig_type=std_logic lab=GND}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 5970 -1360 0 0 {name=M82
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 5970 -1200 0 0 {name=M83
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 5990 -1200 2 0 {name=l61 sig_type=std_logic lab=GND}
C {lab_pin.sym} 3810 -2390 0 0 {name=l62 sig_type=std_logic lab=VRESET}
C {lab_pin.sym} 6400 -2390 0 0 {name=l63 sig_type=std_logic lab=VRESET}
C {lab_pin.sym} 6400 -910 0 0 {name=l64 sig_type=std_logic lab=VRESET}
C {gnd.sym} 5990 -1170 0 0 {name=l65 lab=GND}
C {lab_pin.sym} 5990 -1390 1 0 {name=l66 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 5480 -2300 1 0 {name=l67 sig_type=std_logic lab=FvcoBy2}
C {lab_pin.sym} 5990 -1280 2 0 {name=l68 sig_type=std_logic lab=FvcoBy2_bar}
C {lab_pin.sym} 6400 -830 0 0 {name=l69 sig_type=std_logic lab=FvcoBy2_bar}
C {lab_pin.sym} 8010 -2300 3 0 {name=l70 sig_type=std_logic lab=FvcoBy4_IPH}
C {lab_pin.sym} 3810 -2310 0 0 {name=l79 sig_type=std_logic lab=FvcoBUF}
C {lab_pin.sym} 8320 -2300 3 0 {name=l80 sig_type=std_logic lab=FvcoBy4_IPH_bar}
C {lab_pin.sym} 8060 -820 3 0 {name=l81 sig_type=std_logic lab=FvcoBy4_QPH}
C {lab_pin.sym} 8310 -820 3 0 {name=l82 sig_type=std_logic lab=FvcoBy4_QPH_bar}
C {lab_pin.sym} 6400 -2310 0 0 {name=l83 sig_type=std_logic lab=FvcoBy2}
C {lab_pin.sym} 5930 -1250 0 0 {name=l84 sig_type=std_logic lab=FvcoBy2}
C {lab_pin.sym} 6890 -680 0 0 {name=l85 sig_type=std_logic lab=FvcoBy2_bar}
C {lab_pin.sym} 7300 -830 0 0 {name=l86 sig_type=std_logic lab=FvcoBy2_bar}
C {lab_pin.sym} 6890 -2180 0 0 {name=l87 sig_type=std_logic lab=FvcoBy2}
C {lab_pin.sym} 7300 -2310 0 0 {name=l88 sig_type=std_logic lab=FvcoBy2}
C {lab_pin.sym} 4710 -2310 0 0 {name=l89 sig_type=std_logic lab=FvcoBUF}
C {lab_pin.sym} 4300 -2150 0 0 {name=l90 sig_type=std_logic lab=FvcoBUF}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 4090 -1460 0 0 {name=M84
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 4090 -1300 0 0 {name=M85
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 4110 -1300 2 0 {name=l1 sig_type=std_logic lab=GND}
C {gnd.sym} 4110 -1270 0 0 {name=l2 lab=GND}
C {lab_pin.sym} 4110 -1490 1 0 {name=l3 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 4050 -1350 0 0 {name=l7 sig_type=std_logic lab=Fvco}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 4380 -1460 0 0 {name=M86
L=0.15
W=1.68
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 4380 -1300 0 0 {name=M87
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 4400 -1300 2 0 {name=l8 sig_type=std_logic lab=GND}
C {gnd.sym} 4400 -1270 0 0 {name=l71 lab=GND}
C {lab_pin.sym} 4400 -1490 1 0 {name=l72 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 4400 -1380 2 0 {name=l73 sig_type=std_logic lab=FvcoBUF}
C {code.sym} 2930 -2560 0 0 {
name=TT_model_sky1
format=@value
only_toplevel=true
value="
*.lib ~/open_pdks/sky130/sky130A/libs.tech/ngspice/sky130.lib.spice tt
.param mc_mm_switch=0
.param mc_pr_switch=0

.include ~/open_pdks/sky130/sky130A/libs.tech/ngspice/corners/tt/nonfet.spice


*model
.include ~/open_pdks/sky130/sky130A/libs.tech/ngspice/all.spice

*mosfet
.include ~/open_pdks/sky130/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__tt.corner.spice
.inclued ~/open_pdks/sky130/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__tt.corner.spice
.include ~/open_pdks/sky130/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__tt.corner.spice
.inclued ~/open_pdks/sky130/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__tt.corner.spice

*mismatch parameters
.include ~/open_pdks/sky130/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__mismatch.corner.spice
.include ~/open_pdks/sky130/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__mismatch.corner.spice
.include ~/open_pdks/sky130/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice
.include ~/open_pdks/sky130/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice
.MODEL swmod SW(VT=0.9 VH=0.01 RON=1 ROFF=10000000000)
"
spice_ignore=false

}
C {switch_ngspice.sym} -840 -1290 3 0 {name=S5 model=swmod}
C {gnd.sym} -820 -1120 0 0 {name=l6 lab=GND}
C {switch_ngspice.sym} -360 -1290 3 0 {name=S6 model=swmod}
C {gnd.sym} -340 -1120 0 0 {name=l74 lab=GND}
C {switch_ngspice.sym} -850 -880 3 0 {name=S7 model=swmod}
C {gnd.sym} -830 -710 0 0 {name=l75 lab=GND}
C {switch_ngspice.sym} -370 -880 3 0 {name=S8 model=swmod}
C {gnd.sym} -350 -710 0 0 {name=l76 lab=GND}
C {capa.sym} -700 -1400 2 0 {name=C4
m=1
value=80p
footprint=1206
device="ceramic capacitor"}
C {capa.sym} -610 -960 2 0 {name=C6
m=1
value=80p
footprint=1206
device="ceramic capacitor"}
C {vsource.sym} -510 -990 0 0 {name=vdd_sup1 value=1.8}
C {gnd.sym} -510 -960 0 0 {name=l77 lab=GND}
C {vsource.sym} -590 -1420 0 0 {name=vdd_sup2 value=1.8}
C {gnd.sym} -590 -1390 0 0 {name=l78 lab=GND}
C {cccs.sym} -2310 -980 0 0 {name=F2 vnam=vip1 value=1}
C {gnd.sym} -2160 -1010 0 0 {name=l96 lab=GND}
C {vsource.sym} -2160 -1040 0 0 {name=vin_dc2 value=1.8}
C {gnd.sym} -2160 -1010 0 0 {name=l97 lab=GND}
C {gnd.sym} -2160 -1010 0 0 {name=l98 lab=GND}
C {vsource.sym} -2310 -900 0 0 {name=vip5 value=0}
C {res.sym} -2430 -990 2 0 {name=R5
value=10Meg
footprint=1206
device=resistor
m=1}
C {cccs.sym} -2310 -610 0 0 {name=F4 vnam=vim1 value=1}
C {gnd.sym} -2310 -450 0 0 {name=l99 lab=GND}
C {vsource.sym} -2310 -530 0 0 {name=vip7 value=0}
C {res.sym} -2430 -610 2 0 {name=R8
value=10Meg
footprint=1206
device=resistor
m=1}
C {vsource.sym} -1900 -900 0 0 {name=vip8 value=0}
C {res.sym} -2020 -990 2 0 {name=R9
value=10Meg
footprint=1206
device=resistor
m=1}
C {gnd.sym} -1900 -450 0 0 {name=l100 lab=GND}
C {vsource.sym} -1900 -530 0 0 {name=vip9 value=0}
C {res.sym} -2020 -610 2 0 {name=R10
value=10Meg
footprint=1206
device=resistor
m=1}
C {cccs.sym} -1900 -980 0 0 {name=F5 vnam=vim1 value=1}
C {cccs.sym} -1900 -610 0 0 {name=F6 vnam=vip1 value=1}
C {switch_ngspice.sym} -1560 -320 3 0 {name=S1 model=swmod}
C {gnd.sym} -1540 -150 0 0 {name=l101 lab=GND}
C {switch_ngspice.sym} -1390 -630 3 0 {name=S4 model=swmod}
C {gnd.sym} -1370 -460 0 0 {name=l102 lab=GND}
C {res.sym} -3270 -1090 1 0 {name=R3
value=135k
footprint=1206
device=resistor
m=1}
C {capa.sym} -3210 -1090 1 0 {name=C1
m=1
value=4.7p
footprint=1206
device="ceramic capacitor"}
C {res.sym} -3330 -210 1 0 {name=R1
value=135k
footprint=1206
device=resistor
m=1}
C {capa.sym} -3270 -210 1 0 {name=C2
m=1
value=4.7p
footprint=1206
device="ceramic capacitor"}
C {capa.sym} -3120 -840 2 0 {name=C3
m=1
value=2.35p
footprint=1206
device="ceramic capacitor"}
C {res.sym} -2980 -1090 1 0 {name=R2
value=135k
footprint=1206
device=resistor
m=1}
C {res.sym} -3000 -210 1 0 {name=R4
value=135k
footprint=1206
device=resistor
m=1}
C {vsource.sym} -2880 -1090 3 0 {name=vip1 value=0}
C {gnd.sym} -2750 -1090 0 0 {name=l105 lab=GND}
C {vsource.sym} -2910 -210 3 0 {name=vim1 value=0}
C {gnd.sym} -2760 -210 0 0 {name=l106 lab=GND}
C {xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 140 -2270 3 0 {name=M88
L=0.18
W=40
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vsource.sym} 140 -2220 0 0 {name=vin_pulse9 value="PULSE(1.8 0 0 1NS 1NS 1US 0)" net_name=true

}
C {gnd.sym} 140 -2190 0 0 {name=l109 lab=GND}
C {lab_pin.sym} -980 -1180 3 0 {name=l24 sig_type=std_logic lab=FvcoBy4_IPH}
C {lab_pin.sym} -510 -770 3 0 {name=l28 sig_type=std_logic lab=FvcoBy4_IPH}
C {lab_pin.sym} -3570 -1090 3 0 {name=l91 sig_type=std_logic lab=FvcoBy4_IPH}
C {lab_pin.sym} -980 -770 3 0 {name=l110 sig_type=std_logic lab=FvcoBy4_IPH_bar}
C {lab_pin.sym} -490 -1180 3 0 {name=l111 sig_type=std_logic lab=FvcoBy4_IPH_bar}
C {lab_pin.sym} -3530 -210 3 0 {name=l112 sig_type=std_logic lab=FvcoBy4_IPH_bar}
C {lab_pin.sym} -1470 -520 3 0 {name=l113 sig_type=std_logic lab=FvcoBy4_QPH_bar}
C {lab_pin.sym} -1720 -210 3 0 {name=l103 sig_type=std_logic lab=FvcoBy4_QPH}
C {lab_pin.sym} 200 -1840 1 0 {name=l92 sig_type=std_logic lab=vctrl
}
